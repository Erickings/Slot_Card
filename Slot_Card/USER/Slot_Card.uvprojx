# Keil uVision project Slot_Card.uvprojx, settings and files
target Slot_Card (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Slot_Card +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\HARDWARE\NFC;..\HARDWARE\STATUS;..\HARDWARE\HSJ600;..\HARDWARE\USER_UART;..\HARDWARE\LCD12232;..\HARDWARE\TIMER;..\HARDWARE\RTC;..\HARDWARE\WDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c event_def.h includes.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/STATUS/: status.c status.h
    ../HARDWARE/HSJ600/: hsj600.c hsj600.h
    ../HARDWARE/USER_UART/: user_uart.c user_uart.h
    ../HARDWARE/LCD12232/: lcd12232.c lcd12232.h
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/EXTI/: extiout.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group README
    ../: README.TXT
